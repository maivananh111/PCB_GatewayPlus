File: GatewayPlus.kicad_sch (KiCad schematic)
At the start: 14 parts

Commit message: Add RS485 Layout.
Other:
- added sheet RS485 (RS485.kicad_sch)
- moved on the sheet: H1, H2, H3, H4
